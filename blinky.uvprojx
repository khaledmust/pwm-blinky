# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\Utilities;.\MCAL\;.\ECUAL\LED;.\ECUAL\button;.\MCAL\SYSTICK
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group GPIO
    ./MCAL/GPIO/: GPIO.c GPIO_private.h GPIO.h
  group Utilities
    ./Utilities/: common.h std_types.h
  group Main
    ./: main.c main.h
  group LED
    ./ECUAL/LED/: led.c led.h led_config.c led_config.h
  group Push button
    ./ECUAL/button/: button.c button.h button_config.c button_config.h
  group Application
    ./Application/: application.c application.h
  group SysTick
    ./MCAL/SYSTICK/: systick.c systick.h systick_config.c systick_config.h systick_private.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
